# IAR project LQ_K60.ewp, settings and files
configuration MK60DN (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MK60DN; _DLIB_FILE_DESCRIPTOR; LQ_OLED
  ICCARM.CCDiagSuppress: Ta022, Pe223, Pa082, Ta023
  ICCARM.CCIncludePath2: src\User; src\Project_Setting\Libs; src\Project_Setting\Startup; src\Drive; src\Car; src\fsl
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K60.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: src\Project_Setting\linker\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MK60FX (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 NXP MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 4
  ICCARM.CCDefines: MK60FX; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082, Ta023, Ta022
  ILINK.IlinkIcfFile: src\Project_Setting\linker\PFXflash.icf
  group Drive
    src/Drive/: common.h MK60_ADC.c MK60_ADC.h MK60_CMT.c MK60_CMT.h MK60_DMA.c MK60_DMA.h MK60_FLASH.c MK60_FLASH.h MK60_FTM.c MK60_FTM.h MK60_GPIO.c MK60_GPIO.h MK60_GPIO_Cfg.h MK60_IIC.c MK60_IIC.h MK60_LPTMR.c MK60_LPTMR.h MK60_PIT.c MK60_PIT.h MK60_PLL.c MK60_PLL.h MK60_SPI.c MK60_SPI.h MK60_SYSTICK.c MK60_SYSTICK.h MK60_UART.c MK60_UART.h MK60_WDOG.c MK60_WDOG.h
  group Project_Setting/Startup
    src/Project_Setting/Startup/: fsl_device_registers.h start.c startup_MK60D10.s
    src/Project_Setting/Libs/: MK60N512VMD100.h
  group User
    src/User/: include.h IRQ_Handler.c main.c
  group User/ADC
    src/User/: LQ_ADC.c LQ_ADC.h
  group User/ANO
    src/User/: ANO_DT.c ANO_DT.h
  group User/CAMERA
    src/User/: LQ_CAMERA.c LQ_CAMERA.h
  group User/CAMERA/MT9V034
    src/User/: LQ_MT9V034.c LQ_MT9V034.h
  group User/CCD
    src/User/: LQ_CCD.c LQ_CCD.h
  group User/FLASH
    src/User/: LQ_FLASH.c LQ_FLASH.h
  group User/HC-SR04
    src/User/: LQ_Ultrasonic.c LQ_Ultrasonic.h
  group User/ICM20602
    src/User/: LQ_ICM20602.c LQ_ICM20602.h
  group User/KEY
    src/User/: LQ_KEY.c LQ_KEY.h
  group User/LED
    src/User/: LQ_LED.c LQ_LED.h
  group User/LPTMR
    src/User/: LQ_LPTMR.c LQ_LPTMR.h
  group User/LQ9AX
    src/User/: LQ_9AX.c LQ_9AX.h
  group User/MOTOR
    src/User/: LQ_MOTOR.c LQ_MOTOR.h
  group User/MPU6050
    src/User/: LQ_MPU6050.c LQ_MPU6050.h
  group User/OLED
    src/User/: LQ_12864.c LQ_12864.h
  group User/PIT
    src/User/: LQ_PIT.c LQ_PIT.h
  group User/SD5
    src/User/: LQ_SD5.c LQ_SD5.h
  group User/SmartCar/State
    src/Car/: status.c status.h
  group User/SmartCar/Uart+DMA
    src/fsl/: fsl_edma.c fsl_edma.h
    src/Car/: Uart_DMA.c Uart_DMA.h
  group User/SYSTICK
    src/User/: LQ_SYSTICK.c LQ_SYSTICK.h
  group User/TFT1_8
    src/User/: LQ_SGP18T.c LQ_SGP18T.h picture.h
  group User/UART
    src/User/: LQ_UART.c LQ_UART.h
  group User/VL53
    src/User/: LQ_VL53.c LQ_VL53.h
  group User/WDOG
    src/User/: LQ_WDOG.c LQ_WDOG.h
